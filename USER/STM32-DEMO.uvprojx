# Keil uVision project STM32-DEMO.uvprojx, settings and files
target LED-DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\FWlib\src;..\CMSIS\startup;..\FreeRTOS\inc;..\FreeRTOS\src;..\FreeRTOS;..\FreeRTOS\port;..\HardWare\OLED;..\HardWare\DMA;..\HardWare\RTC;..\HardWare\KEY;..\HardWare\WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c led.c delay.c uart.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
    ../../STM32F103C8T6例程/基本例程-I0操作_LED流水灯/LED流水灯/FWlib/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_crc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/: heap_4.c port.c
  group HardWare
    ../HardWare/DMA/: dma.c
    ../HardWare/KEY/: key.c
    ../HardWare/WIFI/: wifi.c
software components: CMSIS:CORE 4.3.0
